# Keil uVision project Loli3_wooddoor.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Loli3_wooddoor +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 main.c
